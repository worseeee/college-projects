# Keil uVision project lhj.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000) MODA2
  output: money +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: MAIN.C lcd1602.c RC522.C
