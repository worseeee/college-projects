# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\FIWLIB\inc;..\CORE;..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\HARDWARE\LED;..\HARDWARE\BEEP;..\HARDWARE\KEY;..\HARDWARE\EXTI;..\HARDWARE\TIM;..\HARDWARE\LCD;..\HARDWARE\ADC;..\HARDWARE\DAC;..\HARDWARE\FINAL
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FIWLIB
    ../FIWLIB/src/: misc.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_usart.c stm32f4xx_exti.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_fsmc.c stm32f4xx_adc.c stm32f4xx_dac.c
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: LED.c
    ../HARDWARE/BEEP/: BEEP.c
    ../HARDWARE/KEY/: KEY.c KEY_TI.c
    ../HARDWARE/EXTI/: EXTI.c
    ../HARDWARE/TIM/: TIM.c PWM.c
    ../HARDWARE/LCD/: LCD.c
    ../HARDWARE/ADC/: ADC.c TEMP.c
    ../HARDWARE/DAC/: DAC.c
    ../HARDWARE/FINAL/: ALARM.c PERIPH.c SENSOR.c THRESHOLD.c TIMER.c KEY_monitor.c LCD_monitor.c
