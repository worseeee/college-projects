/****************************************************************************
* 文 件 名: main.c
* 作    者: Andy
* 修    订: 2013-01-09
* 版    本: 1.0
* 描    述: LED1闪烁3次后进入睡眠状态，通过按下按键S1产生外部中断进行唤醒
****************************************************************************/
#include <ioCC2530.h>

typedef unsigned char uchar;
typedef unsigned int  uint;

#define LED1 P1_0            //P1.0口控制LED1
#define KEY1 P0_1            //P0.1口控制S1


/****************************************************************************
* 名    称: DelayMS()
* 功    能: 以毫秒为单位延时 16M时约为535,系统时钟不修改默认为16M
* 入口参数: msec 延时参数，值越大，延时越久
* 出口参数: 无
****************************************************************************/
void DelayMS(uint msec)
{ 
    uint i,j;
    
    for (i=0; i<msec; i++)
        for (j=0; j<535; j++);
}

/****************************************************************************
* 名    称: InitLed()
* 功    能: 设置LED灯相应的IO口
* 入口参数: 无
* 出口参数: 无
****************************************************************************/
void InitLed(void)
{
    P1DIR |= 0x01;           //P1.0定义为输出口
    LED1 = 0;                //LED1灯上电默认为熄灭 
}

/****************************************************************************
* 名    称: InitKey()
* 功    能: 设置KEY相应的IO口,采用中断方式 
* 入口参数: 无
* 出口参数: 无
****************************************************************************/
void InitKey()
{
    P0IEN |= 0x02;            // P0.1 设置为中断方式 1：中断使能
    PICTL |= 0x00;            //下降沿触发   
    IEN1 |= 0x20;            //允许P0口中断; 
    P0IFG = 0x00;            //初始化中断标志位
    EA = 1;                  //打开总中断
}

/****************************************************************************
* 名    称: SysPowerMode()
* 功    能: 设置系统工作模式
* 入口参数: mode等于0为PM0 1为PM1 2为PM2 3为PM3             
* 出口参数: 无
****************************************************************************/
void SysPowerMode(uchar mode) 
{ 
    if(mode < 4) 
    {  
        SLEEPCMD |= mode;    //设置系统睡眠模式 
        PCON = 0x01;         //进入睡眠模式 ,通过中断唤醒
    } 
    else 
        PCON = 0x00;         //通过中断唤醒系统 
}

/****************************************************************************
* 名    称: P0_ISR(void) 中断处理函数 
* 描    述: #pragma vector = 中断向量，紧接着是中断处理程序
****************************************************************************/
#pragma vector = P0INT_VECTOR 
__interrupt void P0_ISR(void) 
{ 
    if(P0IFG > 0) 
    { 
        P0IFG = 0;           //清标志位
    } 
    
    P0IF = 0; 
    SysPowerMode(4);         //正常工作模式
} 

/****************************************************************************
* 程序入口函数
****************************************************************************/
void main(void)
{   
    uchar i=0;  
      
    InitLed();		         //设置LED灯相应的IO口     
    InitKey();               //设置KEY相应的IO口
    
    while(1)
    {
        for (i=0; i<6; i++)  //LED1闪烁3次提醒用户将进入睡眠模式
        {
            LED1 = ~LED1;
            DelayMS(500);
        }

        SysPowerMode(2);     //进入睡眠模式PM3,按下按键S1中断唤醒系统 
    }
}
